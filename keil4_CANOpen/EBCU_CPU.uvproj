# Keil uVision project EBCU_CPU.uvproj, settings and files
target Target 1 (166/167)
  device: XC164CS-16F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xC000-0xCFFF) IROM(0xC00000-0xC1FFFF) CLOCK(20000000) MOD167 MODV2
  output: EBCU_CPU +hex
  group Dave Files
    ./: Start_V2.A66 MAIN.C GPT1.C IO.C CC2.C GPT2.C
  group User Files
    ./source/: global.c 8255.c delay.c dpram.c dio.c mvb.c
  group can
    ./CANopen/drivers/XC164/: CAN_Xc164.c PELI.c
  group CANopen
    ./CANopen/src/: emcy.c lss.c objacces.c pdo.c states.c sync.c temp.c timer.c
    ./CANopen/examples/XC164/Slave/: ds401.c ObjDict.c
